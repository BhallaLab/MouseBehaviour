File: CAD/StimIsolator.sch (KiCad schematic (older format))
At the start: 3 parts

Commit message: Some renames.
Parts:
- gave numbers to parts that had none: 2
